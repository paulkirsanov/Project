# Keil uVision project Project 6.uvprojx, settings and files
target Project 6 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project 6 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\Project 6;.\CMSIS;.\CMSIS\src;.\CMSIS\inc;.\Startup;.\UserSource;.\UserSource\inc;.\UserSource\src;.\FreeRTOS;.\FreeRTOS\inc;.\FreeRTOS\src
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Code
    ./UserSource/src/: led.c main.c usart.c stepmotor.c io.c a3144.c timer.c w25q16.c spi.c
  group CMSIS
    ./CMSIS/src/: core_cm3.c system_stm32f10x.c
  group StartUp
    ./Startup/: startup_stm32f10x_md.s
  group FreeRTOS
    ./FreeRTOS/src/: croutine.c event_groups.c heap_1.c list.c port.c queue.c tasks.c timers.c
